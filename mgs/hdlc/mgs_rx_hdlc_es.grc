<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mgs_rx_hdlc_es</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>MGS Rocksat Receiver v1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>125e3</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>center_freq_lbl</value></param>
<param><key>value</key><value>rx_freq/1e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,8,1,2</value></param>
<param><key>label</key><value>Center Frequency [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>khz_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,8,1,4</value></param>
<param><key>label</key><value>Offset [kHz]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>150</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo</value></param>
<param><key>value</key><value>1833e6</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>cutoff_freq</key><value>samp_rate/2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mult</value></param>
<param><key>value</key><value>(samp_rate)/2/3.141593</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>2395e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,4,1,2</value></param>
<param><key>label</key><value>RX Freq [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>2395e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,11,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>76</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>gui_hint</key><value>0,8,1,4</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>86</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>int(samp_rate/baud)</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tuned_center</value></param>
<param><key>value</key><value>baud_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,8,1,2</value></param>
<param><key>label</key><value>        Tuned Center [MHz]</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-3</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>int(record_iq)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>iq_file</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ford/workspace/rocksat/waveforms/captures/rocksat_ota_125kbd_500ksps_20160708_2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>mult</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pl2</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>pl2</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>ip</value></param>
<param><key>mtu</key><value>1024</value></param>
<param><key>port</key><value>port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>256*3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>high</key><value>100</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>-100</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_correlator_filter</key>
<param><key>id</key><value>burst_correlator_filter_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l1</key><value>100</value></param>
<param><key>thresh</key><value>-10</value></param>
<param><key>i1</key><value>1e-4</value></param>
</block>
<block>
<key>burst_length_detect_c</key>
<param><key>id</key><value>burst_length_detect_c_0</value></param>
<param><key>minoutbuf</key><value>5200*4</value></param>
</block>
<block>
<key>burst_preamble_correlator</key>
<param><key>id</key><value>burst_preamble_correlator_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
<param><key>ro</key><value>0.5</value></param>
<param><key>sps</key><value>4</value></param>
</block>
<block>
<key>burst_slicer</key>
<param><key>id</key><value>burst_slicer_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samps_per_symb*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>math.pi*2/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>math.pi*2/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>128</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>256*10</value></param>
<param><key>lookback</key><value>125</value></param>
<param><key>guard</key><value>500</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>2</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>khz_offset*1000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>lpf_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import pmt,struct,numpy,math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip</value></param>
<param><key>label</key><value>ip</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>./rocksat_125kbd_500ksps_date_comment.dat</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>256</value></param>
</block>
<block>
<key>kiss_nrzi_decode</key>
<param><key>id</key><value>kiss_nrzi_decode_0_0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>(baud *(1+alpha) )/2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>mapper_demapper_msg</key>
<param><key>id</key><value>mapper_demapper_msg_0_0</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>message_tools_message_file_sink</key>
<param><key>id</key><value>message_tools_message_file_sink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/sandbox/rocksat/20160708_ota_2.dat</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>port</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>52001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0,1,1,1,1,1,1,0,0,1,1,1,1,1,1,0,0,1,1,1,1,1,1,0,0,1,1,1,1,1,1,0,0,1,1,1,1,1,1,0,0,1,1,1,1,1,1,0]</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0</value></param>
<param><key>gui_hint</key><value>3,8,1,4</value></param>
<param><key>l</key><value>Symbols</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,8,1,4</value></param>
<param><key>l</key><value>Burst Post Length-D</value></param>
</block>
<block>
<key>pyqt_cpsd_plot</key>
<param><key>id</key><value>pyqt_cpsd_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,8,1,4</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_head</key>
<param><key>id</key><value>pyqt_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>1024</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>pyqt_skip_head</key>
<param><key>id</key><value>pyqt_skip_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>100</value></param>
</block>
<block>
<key>pyqt_text_output</key>
<param><key>id</key><value>pyqt_text_output_0</value></param>
<param><key>gui_hint</key><value>16,0,4,8</value></param>
</block>
<block>
<key>pyqt_text_output</key>
<param><key>id</key><value>pyqt_text_output_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>16,8,4,4</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1_0</value></param>
<param><key>gui_hint</key><value>5,8,1,4</value></param>
<param><key>l</key><value>Hard Bits</value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1_0_0</value></param>
<param><key>gui_hint</key><value>4,8,1,4</value></param>
<param><key>l</key><value>Soft Bits</value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>pyqt_trim_tail</key>
<param><key>id</key><value>pyqt_trim_tail_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>msg_complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate </value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>0,0,8,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>pre-d</value></param>
<param><key>label2</key><value>post</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>9,8,1,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>8,0,8,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-60</value></param>
<param><key>int_min</key><value>-130</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>pre-d</value></param>
<param><key>name</key><value></value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>record_iq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>record_rfo</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>record_snr</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfo_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>./rocksat_rfo_date_comment.meta</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>.85</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>snr_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>./rocksat_snr_date_comment.meta</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, rx_offset)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>pre-process</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>raw_in</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>raw_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>rfo</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>burst_bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>pre-process</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>raw_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>raw_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>raw_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>virtual_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>mapper_demapper_msg_0_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pyqt_const_plot_0_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_preamble_correlator_0</source_block_id><sink_block_id>burst_correlator_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_slicer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_slicer_0</source_block_id><sink_block_id>pyqt_time_plot_1_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>virtual_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0</source_block_id><sink_block_id>kiss_nrzi_decode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>burst_length_detect_c_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0_0</source_block_id><sink_block_id>pyqt_text_output_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>kiss_nrzi_decode_0_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>burst_preamble_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0_0</source_block_id><sink_block_id>burst_slicer_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0_0</source_block_id><sink_block_id>pyqt_time_plot_1_0_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_head_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_trim_tail_0</source_block_id><sink_block_id>pyqt_skip_head_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_trim_tail_0</source_block_id><sink_block_id>pyqt_text_output_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>burst_preamble_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
