<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>trx_scram_sock</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>samp_rate/samps_per_symb</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>cutoff_freq</key><value>samp_rate/2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_filter_taps</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>gain</key><value>32</value></param>
<param><key>ntaps</key><value>int(samps_per_symb*32)</value></param>
<param><key>samp_rate</key><value>1.0</value></param>
<param><key>sym_rate</key><value>1.0/(samps_per_symb*32)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0.0.0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-3</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.5</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>addr</value></param>
<param><key>mtu</key><value>256</value></param>
<param><key>port</key><value>port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>addr</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_2</value></param>
<param><key>host</key><value>addr</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>math.pi*2/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>math.pi*2/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>filter_size</key><value>32</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>math.pi*2/100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samps_per_symb</value></param>
<param><key>taps</key><value>rrc_filter_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>lpf_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import pmt,struct,numpy,math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>(baud *(1+alpha) )/2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>mapper_demapper_soft</key>
<param><key>id</key><value>mapper_demapper_soft_0</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>52001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_correct</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2395e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_correct</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2395e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>tx_hier</key>
<param><key>id</key><value>tx_hier_0</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>bb_gain</key><value>.5</value></param>
<param><key>samp_rate</key><value>500e3</value></param>
<param><key>samps_per_symb</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq+rx_correct, rx_offset)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>pre-process</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>pre-process</value></param>
</block>
<block>
<key>vtgs_ao40_decoder</key>
<param><key>id</key><value>vtgs_ao40_decoder_0_0</value></param>
</block>
<block>
<key>vtgs_mult_descrambler</key>
<param><key>id</key><value>vtgs_mult_descrambler_0</value></param>
<param><key>n</key><value>17</value></param>
<param><key>start</key><value>0x3FFFF</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>tx_hier_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_2</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>mapper_demapper_soft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>vtgs_mult_descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_soft_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_hier_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vtgs_ao40_decoder_0_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>valid_frames</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>vtgs_mult_descrambler_0</source_block_id><sink_block_id>vtgs_ao40_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
