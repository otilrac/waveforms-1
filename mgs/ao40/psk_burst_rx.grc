<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_burst_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>125e3</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_filter_taps</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>gain</key><value>32</value></param>
<param><key>ntaps</key><value>samps_per_symb*32</value></param>
<param><key>samp_rate</key><value>1.0</value></param>
<param><key>sym_rate</key><value>1.0/(samps_per_symb*32)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>2395e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>86</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>int(samp_rate/baud)</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
<param><key>minoutbuf</key><value>5200*4</value></param>
</block>
<block>
<key>burst_correlator_filter</key>
<param><key>id</key><value>burst_correlator_filter_0</value></param>
<param><key>l1</key><value>100</value></param>
<param><key>thresh</key><value>-10</value></param>
<param><key>i1</key><value>1e-4</value></param>
</block>
<block>
<key>burst_deframer</key>
<param><key>id</key><value>burst_deframer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>burst_framealign</key>
<param><key>id</key><value>burst_framealign_0</value></param>
<param><key>bs</key><value>5200</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>skip</key><value>len(pre_bits)</value></param>
</block>
<block>
<key>burst_length_detect_c</key>
<param><key>id</key><value>burst_length_detect_c_0</value></param>
<param><key>minoutbuf</key><value>5200*4</value></param>
</block>
<block>
<key>burst_preamble_correlator</key>
<param><key>id</key><value>burst_preamble_correlator_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
<param><key>ro</key><value>0.5</value></param>
<param><key>sps</key><value>4</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_slicer</key>
<param><key>id</key><value>burst_slicer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>burst_synchronizer_v4</key>
<param><key>id</key><value>burst_synchronizer_v4_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>preamble_bits</key><value>pre_bits</value></param>
<param><key>fs</key><value>int(samp_rate)</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>sym_mapping</key><value>[0,1]</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>math.pi*2/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>math.pi*2/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filter_size</key><value>32</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>math.pi*2/100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samps_per_symb</value></param>
<param><key>taps</key><value>rrc_filter_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>128</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>5200*4</value></param>
<param><key>lookback</key><value>100</value></param>
<param><key>guard</key><value>500</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import pmt,struct,numpy,math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>(baud *(1+alpha) )/2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>mapper_demapper_msg</key>
<param><key>id</key><value>mapper_demapper_msg_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>mapper_demapper_msg</key>
<param><key>id</key><value>mapper_demapper_msg_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[1,1,1,1,1,1,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,1,0,1,1,0,0,1,0,0,
1,0,0,0,0,0,0,1,0,0,0,1,0,0,1,1,0,0,0,1,0,1,1,1,0,1,0,1,1,0,1,1,0,0,0]</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>l</key><value>Pre-Sync Syms</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,2</value></param>
<param><key>l</key><value>Final Syms</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>l</key><value>Sym CFO Corr</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>l</key><value>Burst Envelope</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>l</key><value>Burst Post Length-D</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
<param><key>l</key><value>Final Syms</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fn</key><value>lambda x: abs(x)^2</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>l</key><value>XCorr Mags</value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>l</key><value>Soft Bits</value></param>
<param><key>style</key><value>dots</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>8,8,8,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value></value></param>
<param><key>yunit</key><value></value></param>
<param><key>ymax</key><value>.01</value></param>
<param><key>ymin</key><value>-.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, rx_offset)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_deframer_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_framealign_0</source_block_id><sink_block_id>burst_slicer_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>burst_synchronizer_v4_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_const_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_preamble_correlator_0</source_block_id><sink_block_id>burst_correlator_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_randomizer_0</source_block_id><sink_block_id>burst_deframer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_slicer_0</source_block_id><sink_block_id>burst_randomizer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>mapper_demapper_msg_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_const_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_2</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_const_plot_0_0_0</sink_block_id><source_key>debug_post_cfo</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_time_plot_1</sink_block_id><source_key>debug_pre_xcorr</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>burst_length_detect_c_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_pdu_lambda_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0</source_block_id><sink_block_id>burst_framealign_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0</source_block_id><sink_block_id>pyqt_time_plot_1_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0_0</source_block_id><sink_block_id>burst_framealign_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0_0</source_block_id><sink_block_id>pyqt_time_plot_1_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_pdu_lambda_0</source_block_id><sink_block_id>pyqt_cpower_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>burst_preamble_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
